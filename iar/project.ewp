# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M2S120 Microsemi M2S120
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../; ../src/platform/hal/Microsemi/CMSIS; ../src/platform/hal/Microsemi/CMSIS/startup_iar; ../src/platform/hal/Microsemi/drivers; ../src/platform/hal/Microsemi/drivers/mss_hpdma; ../src/platform/hal/Microsemi/drivers/mss_pdma; ../src/platform/hal/Microsemi/drivers/mss_i2c; ../src/platform/hal/Microsemi/drivers/mss_nvm; ../src/platform/hal/Microsemi/drivers/mss_sys_services; ../src/platform/hal/Microsemi/drivers/mss_timer; ../src/platform/hal/Microsemi/drivers/mss_watchdog; ../src/platform/hal/Microsemi/drivers/mss_uart; ../src/platform/hal/Microsemi/drivers/mss_spi; ../src/platform/hal/Microsemi/drivers/mss_rtc; ../src/platform/hal/Microsemi/drivers/mss_gpio; ../src/platform/hal/Microsemi/drivers/mss_usb; ../src/platform/hal/Microsemi/drivers/mss_ethernet_mac; ../src/platform/hal/Microsemi/drivers_config; ../src/platform/hal/Microsemi/drivers_config/sys_config; ../src/platform/hal/Microsemi/hal; ../src/platform/hal/Microsemi/hal/CortexM3; ../src/platform/hal/Microsemi/hal/CortexM3/EWARM; ..\src\include\platform\; ..\src\include\platform\hal\; ..\src\include\platform\osel\; ..\src\include\platform\lib\; ..\src\platform\hal\uC-CPU\; ..\src\platform\hal\uC-CPU\Config\; ..\src\platform\hal\uC-CPU\ARM-Cortex-M3\IAR\; ..\src\platform\lib\uC-LIB\; ..\src\platform\lib\uC-LIB\Config\; ..\src\platform\lib\uC-LIB\Ports\ARM-Cortex-M3\IAR\; ..\src\platform\osel\uCOS-II\Source\; ..\src\platform\osel\uCOS-II\Config\; ..\src\platform\osel\uCOS-II\Ports\ARM-Cortex-M3\IAR\; ..\src\include\stack\; ..\src\stack\common\; ..\src\stack\phy\; ..\src\stack\mac\; ..\src\stack\nwk\; ..\src\stack\nwk\lwip-1.4.1\include; ..\src\stack\nwk\lwip-1.4.1\include\ipv4; ..\src\stack\nwk\lwip-1.4.1\port; ..\src\test\; ..\src\gui\Config\; ..\src\gui\GUI\Core\; ..\src\gui\GUI\LCDDriver\; ..\src\gui\GUI\Widget\; ..\src\gui\GUI\WM\; ..\src\gui\GUI\MemDev\; ..\src\include\gui\; ..\src\app\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ../iar/linker/project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: bstack-m3.out
  group app
    ../src/app/: app.c app_handle.c device.c
  group app/BMP
    ../src/app/BMP/: bootimg.c
  group app/Font
    ../src/app/Font/: SimSun_12.c
  group app/include
    ../src/app/include/: app.h Control_IO.h device.h FontConst.h
  group app/Logic
    ../src/app/Logic/: Control_IO.c
  group app/Surface
    ../src/app/Surface/: FontConst.c SurfaceDlg.c
  group gui
    ../src/gui/: gui_1.c
  group gui/Config
    ../src/gui/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group gui/GUI/AntiAlias
    ../src/gui/GUI/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
  group gui/GUI/ConverColor
    ../src/gui/GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c
  group gui/GUI/Core
    ../src/gui/GUI/Core/: GUI.h GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_ConfDefaults.h GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_FontIntern.h GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_Private.h GUI_Protected.h GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_VNC.h GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI_X.h GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIDebug.h GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIType.h GUIUC0.c GUIVal.c GUIValf.c GUIVersion.h LCD.c LCD.h LCD_API.c LCD_ConfDefaults.h LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Private.h LCD_Protected.h LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c LCDSIM.h
  group gui/GUI/Font
    ../src/gui/GUI/Font/: F08_1.c F08_ASCII.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c F4x6.c F6x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F8x8.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group gui/GUI/LCDDriver
    ../src/gui/GUI/LCDDriver/: LCDDummy.c LCDNull.c LCDWin.c
  group gui/GUI/MemDev
    ../src/gui/GUI/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_16.c GUIDEV_8.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group gui/GUI/MultiLayer
    ../src/gui/GUI/MultiLayer/: LCD_1.c LCD_2.c LCD_3.c LCD_4.c LCD_IncludeDriver.h
  group gui/GUI/Widget
    ../src/gui/GUI/Widget/: BUTTON.c BUTTON.h BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_Private.h BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX.h CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_Private.h CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DIALOG.h DIALOG_Intern.h DROPDOWN.c DROPDOWN.h DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_Private.h DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT.h EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetNumChars.c EDIT_Private.h EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN.h FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_Private.h FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY.h GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c GUI_HOOK.h HEADER.c HEADER.h HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_Private.h HEADER_StreamedBitmap.c LISTBOX.c LISTBOX.h LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_Private.h LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW.h LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_Private.h LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU.h MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_Private.h MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MESSAGEBOX.h MULTIEDIT.c MULTIEDIT.h MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE.h MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c MULTIPAGE_Private.h PROGBAR.c PROGBAR.h PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO.h RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_Private.h RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR.h SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_Private.h SCROLLBAR_SetWidth.c SLIDER.c SLIDER.h SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT.h TEXT_Create.c TEXT_CreateIndirect.c TEXT_Private.h TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c WIDGET.c WIDGET.h WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c WINDOW_Private.h
  group gui/GUI/WM
    ../src/gui/GUI/WM/: WM.c WM.h WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_GUI.h WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_Intern.h WM_Intern_ConfDep.h WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
  group include/platform
    ../src/include/platform/: platform.h
  group include/platform/hal
    ../src/include/platform/hal/: hal_ethernet.h hal_gpio.h hal_mem.h hal_misc.h hal_rf.h hal_timer.h hal_uart.h hal_usb.h
  group include/platform/lib
    ../src/include/platform/lib/: check.h crc.h debug.h list.h memory.h queue.h
  group include/platform/osel
    ../src/include/platform/osel/: osel_event.h osel_kernel.h osel_task.h
  group include/stack/mac
    ../src/stack/mac/: mac.h
  group include/stack/nwk
    ../src/stack/nwk/: addr.h affiliate.h neighbor.h nwk.h nwk_eth.h nwk_mesh.h route.h
  group include/stack/phy
    ../src/stack/phy/: phy.h
  group init
    ../src/init/: startup.c
  group platform/hal
    ../src/platform/hal/: hal_audio.c hal_ethernet.c hal_gpio.c hal_lcd.c hal_mem.c hal_misc.c hal_rf.c hal_sensor.c hal_timer.c hal_uart.c hal_usb.c hal_usb_cfg.c
  group platform/hal/Microsemi
    ../src/platform/hal/Microsemi/hal/CortexM3/: cortex_nvic.c cortex_nvic.h
    ../src/platform/hal/Microsemi/hal/CortexM3/EWARM/: hal.s hw_reg_access.s
  group platform/hal/Microsemi/CMSIS
    ../src/platform/hal/Microsemi/CMSIS/: hw_reg_io.h m2sxxx.h mss_assert.h sys_init_cfg_types.h system_m2sxxx.c system_m2sxxx.h
    ../src/platform/hal/Microsemi/CMSIS/startup_iar/: read.c startup_m2sxxx.s write.c
  group platform/hal/Microsemi/drivers
    ../src/platform/hal/Microsemi/drivers/mss_gpio/: mss_gpio.c
    ../src/platform/hal/Microsemi/drivers/mss_hpdma/: mss_hpdma.c
    ../src/platform/hal/Microsemi/drivers/mss_i2c/: mss_i2c.c
    ../src/platform/hal/Microsemi/drivers/mss_nvm/: mss_nvm.c
    ../src/platform/hal/Microsemi/drivers/mss_pdma/: mss_pdma.c
    ../src/platform/hal/Microsemi/drivers/mss_rtc/: mss_rtc.c
    ../src/platform/hal/Microsemi/drivers/mss_spi/: mss_spi.c
    ../src/platform/hal/Microsemi/drivers/mss_uart/: mss_uart.c
    ../src/platform/hal/Microsemi/drivers_config/sys_config/: sys_config.c
  group platform/hal/Microsemi/drivers/inc
    ../src/platform/hal/Microsemi/drivers/mss_sys_services/: mss_comblk.h mss_sys_services.h
    ../src/platform/hal/Microsemi/drivers/mss_gpio/: mss_gpio.h
    ../src/platform/hal/Microsemi/drivers/mss_hpdma/: mss_hpdma.h
    ../src/platform/hal/Microsemi/drivers/mss_i2c/: mss_i2c.h
    ../src/platform/hal/Microsemi/drivers/mss_nvm/: mss_nvm.h
    ../src/platform/hal/Microsemi/drivers/mss_pdma/: mss_pdma.h
    ../src/platform/hal/Microsemi/drivers/mss_rtc/: mss_rtc.h
    ../src/platform/hal/Microsemi/drivers/mss_spi/: mss_spi.h
    ../src/platform/hal/Microsemi/drivers/mss_timer/: mss_timer.h
    ../src/platform/hal/Microsemi/drivers/mss_uart/: mss_uart.h mss_uart_regs.h
    ../src/platform/hal/Microsemi/drivers/mss_watchdog/: mss_watchdog.h
  group platform/hal/Microsemi/eth
    ../src/platform/hal/Microsemi/drivers/mss_ethernet_mac/: ksz8051mnl_phy.c m88e1340_phy.c mss_ethernet_mac.c mss_ethernet_mac.h mss_ethernet_mac_regs.h mss_ethernet_mac_types.h mss_ethernet_mac_user_config.h mss_ethernet_phy.h
  group platform/hal/Microsemi/usb
    ../src/platform/hal/Microsemi/drivers/mss_usb/: mss_usb_common_cif.c mss_usb_common_cif.h mss_usb_common_reg_io.h mss_usb_config.h mss_usb_core_regs.h mss_usb_device.c mss_usb_device.h mss_usb_device_cdc.c mss_usb_device_cdc.h mss_usb_device_cif.c mss_usb_device_cif.h mss_usb_device_hid.c mss_usb_device_hid.h mss_usb_device_reg_io.h mss_usb_std_def.h
  group platform/hal/uC-CPU
    ../src/platform/hal/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../src/platform/hal/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group platform/hal/uC-CPU/Config
    ../src/platform/hal/uC-CPU/Config/: cpu_cfg.h
  group platform/lib
    ../src/platform/lib/: check.c debug.c list.c memory.c queue.c
  group platform/lib/uC-LIB
    ../src/platform/lib/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group platform/lib/uC-LIB/Config
    ../src/platform/lib/uC-LIB/Config/: lib_cfg.h
  group platform/lib/uC-LIB/Ports
    ../src/platform/lib/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group platform/osel
    ../src/platform/osel/: osel_event.c osel_kernel.c osel_task.c
  group platform/osel/uC-OS
    ../src/platform/osel/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group platform/osel/uC-OS/Config
    ../src/platform/osel/uCOS-II/Config/: app_cfg.h os_cfg.h
  group platform/osel/uC-OS/Ports
    ../src/platform/osel/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group stack/common
    ../src/stack/common/: kbuf.c kbuf.h
  group stack/mac
    ../src/stack/mac/: mac.c mac_handle.c mac_meas.c
  group stack/nwk
    ../src/stack/nwk/: addr.c affiliate.c neighbor.c nwk.c nwk_eth.c nwk_handle.c nwk_mesh.c route.c
  group stack/nwk/lwip-1.4.1/api
    ../src/stack/nwk/lwip-1.4.1/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group stack/nwk/lwip-1.4.1/core
    ../src/stack/nwk/lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group stack/nwk/lwip-1.4.1/core/ipv4
    ../src/stack/nwk/lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/stack/nwk/lwip-1.4.1/core/: pbuf.c timers.c
  group stack/nwk/lwip-1.4.1/netif
    ../src/stack/nwk/lwip-1.4.1/netif/: etharp.c
  group stack/nwk/lwip-1.4.1/port/arch
    ../src/stack/nwk/lwip-1.4.1/port/arch/: sys_arch.c
  group stack/phy
    ../src/stack/phy/: phy.c
  group test
    ../src/test/: netio.c test.c test.h
